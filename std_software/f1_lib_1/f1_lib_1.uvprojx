# Keil uVision project f1_lib_1.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f1_lib_1 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\lib;..\f1_sft_1\Core\Inc;..\f1_sft_1\Drivers\STM32F1xx_HAL_Driver\Inc;..\f1_sft_1\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\f1_sft_1\Middlewares\Third_Party\FreeRTOS\Source\include;..\f1_sft_1\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\f1_sft_1\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\f1_sft_1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\f1_sft_1\Drivers\CMSIS\Include;..\f1_sft_1\Core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./lib/: stdlib_common.c stdlib_i2c.c stdlib_tim.c stdlib_usart.c stdlib_config.h
